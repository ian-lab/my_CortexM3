# Keil uVision project cm3.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cm3
  AfterMake: fromelf -cvf .\cm3.axf --vhx --32x1 -o image.hex
  AfterMake: fromelf -cvf .\cm3.axf -o image.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --C99
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ../Software/: core_cm3.h core_cmFunc.h core_cmInstr.h CortexM3.h CortexM3_driver.c CortexM3_driver.h handler.c main.c Retarget.c startup_CM3DS.s system.c
